# Keil uVision project iSO-STM32.uvprojx, settings and files
target Smart_Yacht (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\Driver\USART;..\..\Driver\OLED;..\..\Driver\LED;..\..\Driver\WIFI;..\..\Driver\SysTick;..\..\Driver\KEY;..\..\Driver\PWM;..\..\Driver\FLASH;..\..\Driver\RC522;..\..\Driver\SPI;..\..\Driver\RTC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_i2c.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_bkp.c stm32f10x_pwr.c
  group USER
    ../../User/: stm32f10x_conf.h main.c main.h stm32f10x_it.c stm32f10x_it.h bsp_init.c card_records.c
  group DRIVER
    ../../Driver/LED/: led.c
    ../../Driver/USART/: usart.c ZigBee_BufferPool.c WIFI_BufferPool.c
    ../../Driver/OLED/: OLED.c
    ../../Driver/WIFI/: wifi.c
    ../../Driver/SysTick/: SysTick.c
    ../../Driver/KEY/: exti.c
    ../../Driver/PWM/: Breathing_Light.c PWM.c
    ../../Driver/FLASH/: flash.c
    ../../Driver/SPI/: spi.c
    ../../Driver/RC522/: rc522.c opp.c
    ../../Driver/RTC/: rtc.c
  group Doc
    ../../Doc/: Readme.txt
software components: CMSIS:CORE 4.1.0
